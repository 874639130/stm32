# Keil uVision project BH-F429.uvprojx, settings and files
target TCP_Client (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TCP_Client +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\UCOSII\uC-LIB;..\..\UCOSII\uC-CPU;..\..\UCOSII\UCOS_BSP;..\..\UCOSII\uCOS-CONFIG;..\..\UCOSII\uCOS-II\Source;..\..\UCOSII\uC-CPU\ARM-Cortex-M4\RealView;..\..\UCOSII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\UCOSII\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\USER;..\..\USER\App;..\..\USER\Uartx;..\..\USER\UserApp;..\..\LWIP\lwip_app\lwip_comm;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\src\include\lwip;..\..\LWIP\lwip-1.4.1\src\include\netif;..\..\LWIP\lwip_app\tcp_client_demo;..\..\LWIP\lwip_app\web_server_demo;..\..\LWIP\arch;..\..\LWIP;..\..\HARAWARE\systick;..\..\HARAWARE\ETH;..\..\HARAWARE\led;..\..\HARAWARE\Uartx;..\..\HARAWARE\PCF8574;..\..\HARAWARE\IIC;..\..\HARAWARE\STMFLASH;..\..\HARAWARE\SDRAM;..\..\HARAWARE;..\..\UserApp;..\..\MALLOC;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../USER/: main.c stm32f4xx_it.c
  group MALLOC
    ../../MALLOC/: malloc.c
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
  group UserApp
    ../../UserApp/: CommPro.c SeverComm.c chargingPiletoUpperComputer.c LockComm.c
  group LWIP-APP
    ../../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../../LWIP/lwip_app/tcp_client_demo/: tcp_client_demo.c
    ../../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group HEADWARE
    ../../HARAWARE/led/: bsp_led.c
    ../../HARAWARE/Uartx/: UartDriver.c
    ../../HARAWARE/STMFLASH/: stmflash.c
    ../../HARAWARE/: rtc.c
    ../../HARAWARE/ETH/: lan8720.c stm32f4x7_eth.c
    ../../HARAWARE/PCF8574/: pcf8574.c
    ../../HARAWARE/IIC/: myiic.c
    ../../HARAWARE/SDRAM/: sdram.c
  group UCOSII_BSP
    ../../UCOSII/UCOS_BSP/: bsp.c cpu_bsp.c
  group UCOSII_CPU
    ../../UCOSII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
    ../../UCOSII/uC-CPU/: cpu_core.c
  group UCOSII_LIB
    ../../UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../UCOSII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSII_CORE
    ../../UCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../../UCOSII/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII_CONFIG
    ../../UCOSII/uCOS-CONFIG/: app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group LWIP_NETIF
    ../../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group DOC
    ../../: 必读说明.txt
software components: CMSIS:CORE 4.1.0
